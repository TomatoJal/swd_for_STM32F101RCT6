# IAR project HTxxxx.ewp, settings and files
configuration HT6x3x (ARM, debug)
  General.OGChipSelectEditMenu: HT6X3X Hitrendtech HT6X3X
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: HT6x3x
  ICCARM.CCIncludePath2: ..\Source\library\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HTxxxx.bin
  ILINK.IlinkOutputFile: HTxxxx.out
  ILINK.IlinkIcfFile: E:\06.MPPC\MPPC_HTxxxx\HTxxxx\Project\HT6X3X.icf
  ILINK.IlinkProgramEntryLabel: FlashInitEntry
  group (top)
    ./: HT6X3X.icf
  group Framework
    ../Source/framework/: flash_loader.c flash_loader_asm.s
  group lib
    ../Source/library/src/: core_cm0.c ht6xxx_cmu.c ht6xxx_flash.c system_ht6xxx.c
