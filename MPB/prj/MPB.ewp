# IAR project MPB.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F101xC ST STM32F101xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: DEBUG=1; CM4; USE_TARGET_RAM
  ICCARM.CCIncludePath2: ..\source\library\inc; ..\source\swd\inc; ..\source\target\inc; ..\source\user\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: MPB_DB.bin
  ILINK.IlinkOutputFile: MPB.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  ICCARM.CCDefines: RELEASE=1
  ICCARM.CCIncludePath2: ..\library\inc; ..\inc
  ICCARM.CCOptLevel: 2
  OBJCOPY.OOCOutputFile: MPB_RL.hex
  ILINK.IlinkIcfFile: stm32f10x_flash.icf
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
  group FWLIB
    ../source/library/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group SWD
    ../source/swd/src/: swd_app.c swd_dap.c swd_pin.c
  group TARGET/Firmware
    ../source/target/src/: firmware.c
  group TARGET/RTC
    ../source/target/src/: measure_freq.c RTC.c
  group USER
    ../source/user/src/: dwn_assist.c event.c ict_communication.c m25pxx.c main.c md5.c misc.c progmcu.c stm32f10x_it.c
